# Keil uVision project SE73_BOOT.uvprojx, settings and files
target SE73_BOOT (6160000::V6.16::.\ARMCompiler6.16)
  device: OM6239 Onmicro
  pack: Onmicro.OM6239.1.0.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x3000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: SE73_BOOT
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: CONFIG_OM6239=1,CONFIG_HARDWARE_VERSION=1,CONFIG_BOARD_OM6239_EVB=1,CONFIG_EVT=1,CONFIG_EXBLE2=1,CONFIG_PM=1,CONFIG_OM_PRINTF=0,CONFIG_OM_ASSERT=0,CONFIG_MOUSE_AUTO_CIRCLE=0,
  c include: ../config;../config;../main;../periph;../../../common/includes;../../../hal/CMSIS/Core/Include;../../../hal/device/include;../../../hal/driver/include;../../../hal/driver/common;../../../components/evt;../../../components/exble2/includes;../../../components/exble2/port;../../../components/tinycrypt/include;../../../components/om_cfg;../../../components/pm;../../../bsp;..\..\..\mode_24g;..\..\..\mode_usb;..\flash;..\led
  asm define: as above
  asm include: ../config;../config;../main;../periph;../../../common/includes;../../../hal/CMSIS/Core/Include;../../../hal/device/include;../../../hal/driver/include;../../../hal/driver/common;../../../components/evt;../../../components/exble2/includes;../../../components/exble2/port;../../../components/tinycrypt/include;../../../components/om_cfg;../../../components/pm;../../../bsp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group boot
    ./: boot_img.s
